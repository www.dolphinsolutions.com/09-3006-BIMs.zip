Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-02-16T14:48:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Feb 16 14:48:21 2017* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{DE59EC45-DC34-441B-857A-B71BDE92FC52}\ifc* Database version: 5507* Database creation date: Thu Feb 16 14:48:20 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Feb 16 14:48:20 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Feb 16 14:48:20 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: BrushedSatin, NBS_FCFrostLtd_WasteBins_RecessedStainlessSteelWasteBin:BrushedSatin:299783
In: Level 0
Type - ElementType: BrushedSatin; Classification: Pr_40_50_07_96 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FCFrostLtd_WasteBins_RecessedStainlessSteelWasteBin_BrushedSatin; ManufacturerName: FC Frost Ltd; ManufacturerURL: www.fcfrost.com; NBSCertification: www.nationalbimlibrary.com/cert/0kaswj00; NBSDescription: Waste bins; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/380; NBSTypeID: n/a; ProductInformation: www.fcfrost.com/09.3006.html; Revision: n/a; Uniclass2015Code: Pr_40_50_07_96; Uniclass2015Title: Waste bins; Uniclass2015Version: Products v1.5; Version: 1
Type - NBS_Data - EnvironmentalProductDeclaration: n/a; Form: Recessed; IntegralAccessories: n/a; Capacity: 10 litres; SizeOptions: Bins can be made to suit customer’s dimensional requirements; StucturalOpeningSizeRecommendation: 360 x 665 x 112 mm; RecommendedMountingHeight: From underside of unit to finished floor level: Male: 315 mm; Spares: Contact FC Frost for spares requirements: service@fcfrost.com
Type - Pset_FurnitureTypeCommon - Description: Recessed, satin stainless steel, waste paper bin with removable 10 litre capacity bin and stainless steel back box; Style: n/a; NominalHeight: 680 mm; NominalDepth: 118 mm; MainColor: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: WASTEPAPERBIN
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Specialty Equipment; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Recess mounted waste paper bin. Flush mounted lock, vertically brushed satin finish stainless steel door, waste chute and stainless steel back box and bin; Finish: Brushed satin; Grade: n/a; Manufacturer: info@fcfrost.com; Material: Stainless steel grade 1.4301 (304); ModelNumber: 9.3006; ModelReference: Recessed Stainless Steel Waste Bin; Name: WasteBins_RecessedStainlessSteelWasteBin_BrushedSatin_FCFrostLtd; NominalWidth: 375 mm; Shape: n/a; Size: 375 x 118 x 680 mm; SustainabilityPerformance: n/a; WarrantyDescription: This product is covered by a 12 month warranty from the date of purchase to be free from defects if installed and maintained in accordance with the products instructions. FC Frost will replace or repair (as appropriate) free of charge any product with a proven manufacturing defect if reported within the warranty period; WarrantyDurationLabor: n/a; WarrantyDurationParts: year; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyGuarantorParts: n/a
